# Keil uVision project rm48x.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: RM48L950 Texas Instruments
  cpu: IRAM(0x08000000-0x0803FFFF) IROM(0-0x002FFFFF) CLOCK(16000000) CPUTYPE("Cortex-R4F") ELITTLE
  output: RM48x +hex
  AfterMake: c:\Keil\ARM\BIN40\fromelf.exe --bin --output debug\RM48x.out RM48x.axf
  c flags: Optim=1
  c include: .\include
  memory RVCT4: ROM 0x0 size 0x300000
  memory RVCT9: RAM 0x8000000 size 0x40000
  group Source Group 1
    ./: startup_RM48.s
  group Source
    ./source/: adc.c can.c can_protocol.c dcc.c debug.c dmm.c emac.c emif.c errors.c esm.c gio.c het.c i2c.c lin.c mac.c mdio.c mibspi.c parity_functions.c phy_dp83640.c pinmux.c pom.c rti.c rtp.c sci.c sci_print.c sci_receive.c self_test.c spi.c stc.c sys_main.c sys_phantom.c sys_startup.c system.c sys_core.asm sys_intvecs.asm sys_memory.asm sys_mpu.asm sys_pmu.asm
  group Include
    ./include/: adc.h can.h can_protocol.h ccm.h dcc.h debug.h dmm.h emac.h emif.h errors.h esm.h gio.h het.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mac.h mdio.h mibspi.h parity_functions.h pbist.h phy_dp83640.h pinmux.h pom.h rti.h rtp.h sci.h sci_print.h sci_receive.h self_test.h spi.h stc.h std_nhet.h sys_common.h sys_core.h sys_memory.h sys_mpu.h sys_pmu.h sys_vim.h system.h
