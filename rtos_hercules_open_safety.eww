<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\rtos_hercules_open_safety.ewp</path>
  </project>
  <batchBuild/>
</workspace>


