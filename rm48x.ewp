# IAR project rm48x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM48L950PGE TexasInstruments RM48L950PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rm48x.srec
  ILINK.IlinkOutputFile: rm48x.out
  ILINK.IlinkIcfFile: C:\Hercules\IAR\rm48x\config\RM48L950_flash.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    source/: adc.c can.c can_protocol.c ccm.c dcc.c debug.c dmm.c emac.c emif.c esm.c gio.c het.c i2c.c lin.c mac.c mdio.c mibspi.c os_croutine.c os_heap.c os_list.c os_port.c os_portasm.asm os_portasm.inc os_queue.c os_tasks.c os_timer.c parity_functions.c phy_dp83640.c pinmux.c pom.c rtp.c sci.c sci_print.c sci_receive.c spi.c stc.c sys_core.asm sys_intvecs.asm sys_main.c sys_memory.asm sys_mpu.asm sys_phantom.c sys_pmu.asm sys_startup.c system.c task1.c task2.c task3.c task4.c
    include/: adc.h can.h ccm.h dcc.h dmm.h emac.h emif.h esm.h FreeRTOS.h FreeRTOSConfig.h gio.h het.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mac.h mdio.h mibspi.h os_croutine.h os_list.h os_mpu_wrappers.h os_portable.h os_portmacro.h os_projdefs.h os_queue.h os_semphr.h os_StackMacros.h os_task.h os_timer.h parity_functions.h phy_dp83640.h pinmux.h pom.h rtp.h sci.h sci_print.h sci_receive.h spi.h stc.h std_nhet.h sys_common.h sys_core.h sys_memory.h sys_mpu.h sys_pmu.h sys_vim.h system.h task1.h task2.h task3.h task4.h
