# IAR project lwip_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM48L950PGE TexasInstruments RM48L950PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Hercules\IAR\lwip_example\lwip-1.3.2\src\include\ipv4; C:\Hercules\IAR\lwip_example\lwip-1.3.2; C:\Hercules\IAR\lwip_example\include; C:\Hercules\IAR\lwip_example\lwip-1.3.2\apps\httpserver_raw_io; C:\Hercules\IAR\lwip_example\lwip-1.3.2\ports\hdk\include; C:\Hercules\IAR\lwip_example\lwip-1.3.2\src\include; C:\Hercules\IAR\lwip_example\example\hdk\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: lwip_example.srec
  ILINK.IlinkOutputFile: lwip_example.out
  ILINK.IlinkIcfFile: C:\Hercules\IAR\lwip_example\config\RM48L950_flash.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    source/: adc.c can.c can_protocol.c dcc.c debug.c dmm.c emac.c emif.c errors.c esm.c gio.c het.c i2c.c lin.c mac.c mdio.c mibspi.c pinmux.c pom.c rti.c rtp.c sci.c sci_print.c sci_receive.c spi.c sys_core.asm sys_intvecs.asm sys_main.c sys_memory.asm sys_mpu.asm sys_phantom.c sys_pmu.asm sys_startup.c system.c
    include/: adc.h can.h can_protocol.h dcc.h debug.h dmm.h emac.h emif.h errors.h esm.h gio.h het.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mac.h mdio.h mibspi.h pinmux.h pom.h rti.h rtp.h sci.h sci_print.h sci_receive.h spi.h std_nhet.h sys_common.h sys_core.h sys_memory.h sys_mpu.h sys_pmu.h sys_vim.h system.h
    lwip-1.3.2/ports/hdk/include/arch/: bpstruct.h cc.h epstruct.h
    lwip-1.3.2/apps/httpserver_raw_io/: httpd.h httpd_io.c httpd_structs.h
    ./: lwip-1.3.2
    lwip-1.3.2/ports/hdk/: lwiplib.c
    lwip-1.3.2/ports/hdk/include/: lwiplib.h
    lwip-1.3.2/ports/hdk/netif/: phy_dp83640.c
    lwip-1.3.2/ports/hdk/include/netif/: phy_dp83640.h
