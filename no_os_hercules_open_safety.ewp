# IAR project no_os_hercules_open_safety.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RM48L950PGE TexasInstruments RM48L950PGE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: C:\Hercules\IAR\no_os_hercules_open_safety\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: no_os_hercules_open_safety.srec
  ILINK.IlinkOutputFile: no_os_hercules_open_safety.out
  ILINK.IlinkIcfFile: C:\Hercules\IAR\no_os_hercules_open_safety\config\RM48L950_flash.icf
  ILINK.IlinkProgramEntryLabel: _c_int00
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    source/: adc.c can.c can_protocol.c ccm.c core.asm dcc.c debug.c dmm.c emac.c emif.c errors.c esm.c gio.c het.c i2c.c lin.c mac.c mdio.c mibspi.c parity_functions.c pbist.c phy_dp83640.c pinmux.c pom.c rti.c rtp.c sci.c sci_print.c sci_receive.c self_test.c spi.c stc.c sys_core.asm sys_intvecs.asm sys_main.c sys_memory.asm sys_mpu.asm sys_phantom.c sys_pmu.asm sys_startup.c system.c
    include/: adc.h can.h can_protocol.h ccm.h dcc.h debug.h dmm.h emac.h emif.h errors.h esm.h gio.h het.h hw_emac.h hw_emac_ctrl.h hw_mdio.h hw_reg_access.h i2c.h lin.h mac.h mdio.h mibspi.h pbist.h phy_dp83640.h pinmux.h pom.h rti.h rtp.h sci.h sci_print.h sci_receive.h self_test.h spi.h stc.h std_nhet.h svc.c svc.h sys_common.h sys_core.h sys_memory.h sys_mpu.h sys_pmu.h sys_vim.h system.h
